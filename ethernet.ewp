# IAR project ethernet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=8000000; STM32F40_41xxx
  ICCARM.CCIncludePath2: FreeRTOS\include\; FreeRTOS\portable\IAR\ARM_CM4F\; STM32F4x7_ETH_Driver\inc\; CMSIS\Include\; CMSIS\Device\ST\STM32F4xx\Include\; STM32F4xx_StdPeriph_Driver\inc\; STM32F4-Discovery\; $PROJ_DIR$; lwip\port\; lwip\port\include\arch\; lwip\port\include\; lwip\src\include\; lwip\src\include\ipv4\; lwip\src\include\lwip\; lwip\src\include\netif\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: FreeRTOS\include\; FreeRTOS\portable\IAR\ARM_CM4F\
  OBJCOPY.OOCOutputFile: ethernet.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group CMSIS
    STM32F4xx_StdPeriph_Driver/src/: misc.c
    startup/: startup_stm32f4xx.s
    CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group FreeRTOS
    FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/MemMang
    FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/portable
    FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group lwip/api
    lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/core/ipv4
    lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip/netif
    lwip/src/netif/: etharp.c slipif.c
  group lwip/port
    lwip/port/: ethernetif.c sys_arch.c
  group STM32F4-Discovery
    STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery.h
  group STM32F4x7_ETH_Driver
    STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ./: stm32f4x7_eth_bsp.c
  group STM32F4xx_StdPeriph_Driver
    STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ./: lwipopts.h main.c main.h stm32f4xx_it.c
